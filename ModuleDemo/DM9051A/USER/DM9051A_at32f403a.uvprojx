# Keil uVision project DM9051A_at32f403a.uvprojx, settings and files
target AT32F403A_DM9051 (5060960::V5.06 update 7 (build 960)::.\ARMCC5.06)
  cpu: CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: AT32F403A_DM9051 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,DM9051_AT32F403A_DIAG=1,DM9051_TX_WAIT_DONE=1,DM9051_AT32F403A_USE_DMA=1,DM9051_AT32F403A_USE_IRQ=1
  c include: ..\USER;..\..\..\Libraries\AT32F403A\inc;;..\dm9051_driver\core\inc;..\dm9051_driver\hal\inc;..\dm9051_driver\ports\at32f403a;..\dm9051_driver\examples\at32f403a_demo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group USER
    ./: main.c mh20xx_it.c main_uip_mh2030a.c
    ../../../Libraries/MH20xxLib/src/: system_mh20xx.c
    ../dm9051_driver/examples/at32f403a_demo/: main_at32f403a_smoke.c
  group BSP
    ../bsp/: dm9051a.c mh2030a_spi1.c mh2030a_spi1_dma.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
  group CORE
    ../../../Libraries/CORE/: startup_mh20xx.s
  group FWLib
    ../../../Libraries/MH20xxLib/src/: mh20xx_usart.c mh20xx_rcc.c mh20xx_gpio.c mh20xx_dma.c mh20xx_misc.c mh20xx_syscfg.c mh20xx_exti.c mh20xx_flash.c mh20xx_spi.c mh20xx_pwr.c mh20xx_crc.c mh20xx_adc.c mh20xx_comp.c mh20xx_i2c.c mh20xx_iwdg.c mh20xx_rtc.c mh20xx_tim.c mh20xx_wwdg.c mh20xx_dbgmcu.c
  group MH2030A_PORT
    ../port/mh2030a/: mh2030a_board.c mh2030a_dm9051_spi.c mh2030a_dm9051_int.c mh2030a_dm9051_spi_dma.c
    ../port/uip/: clock-arch.c netconf_mh2030a.c dm9051_uip_adapter.c
    ../dm9051_driver/ports/at32f403a/: dm9051_hal_at32f403a_spi1.c dm9051_hal_at32f403a_spi1_dma.c dm9051_hal_at32f403a_int.c at32f403a_board.c
  group DM9051_CORE
    ../../../drivers/dm9051_edriver_v1.6.1a_beta/core/: dm9051_beta.c
    ../dm9051_driver/core/src/: dm9051_core.c dm9051_debug.c
    ../dm9051_driver/hal/src/: dm9051_hal.c
  group uIP_CORE
    ../../../middlewares/3rd_party/uip/src/: uip.c uip_arp.c timer.c psock - EditA.c
  group uIP_APP
    ../../../apps/uip_dm9051_example_e1/uip_app_src/: uip-conf.c app_call.c
    ../../../apps/uip_dm9051_example_e1/uip_app_src/Eth_app/debug_app/: debug_app.c
    ../../../apps/uip_dm9051_example_e1/uip_app_src/Eth_app/resolv/: resolv.c
  group WEB_APP
    ../../../apps/uip_dm9051_example_e1/uip_app_src/webserver/src/DM/: httpd.c httpd-fs.c httpd-cgi-test1.c http-strings.c
