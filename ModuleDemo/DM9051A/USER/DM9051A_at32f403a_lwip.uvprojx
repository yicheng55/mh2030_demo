# Keil uVision project DM9051A_at32f403a_lwip.uvprojx, settings and files
target AT32F403A_DM9051_LWIP (5060960::V5.06 update 7 (build 960)::.\ARMCC5.06)
  cpu: CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: AT32F403A_DM9051_LWIP +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,AT32F403A_LWIP_PORT,NO_SYS=1,DM9051_AT32F403A_DIAG=1,DM9051_TX_WAIT_DONE=1,DM9051_AT32F403A_USE_DMA=1,DM9051_AT32F403A_USE_IRQ=1
  c include: ..\USER;..\..\..\Libraries\AT32F403A\inc;;..\dm9051_driver\core\inc;..\dm9051_driver\hal\inc;..\dm9051_driver\ports\at32f403a;..\dm9051_driver\adapters\lwip;..\dm9051_driver\examples\at32f403a_demo;..\..\..\middlewares\3rd_party\lwip-2.1.2\src\include;..\..\..\middlewares\3rd_party\lwip-2.1.2\port;..\..\..\apps\lwip_web2403v2_freelw
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group USER
    ../../../Libraries/MH20xxLib/src/: system_mh20xx.c
    ../dm9051_driver/examples/uip_mh2030a_demo/: main_uip_mh2030a_smoke.c main_uip_mh2030a_demo.c
    ../dm9051_driver/examples/lwip_mh2030a_demo/: main_dm9051_lwip_example.c
    ../dm9051_driver/ports/mh2030a/: mh20xx_it.c
    ../dm9051_driver/examples/at32f403a_demo/: main_at32f403a_lwip_demo.c
  group SYSTEM
    ../dm9051_driver/ports/mh2030a/: delay.c
  group CORE
    ../../../Libraries/CORE/: startup_mh20xx.s
  group FWLib
    ../../../Libraries/MH20xxLib/src/: mh20xx_usart.c mh20xx_rcc.c mh20xx_gpio.c mh20xx_dma.c mh20xx_misc.c mh20xx_syscfg.c mh20xx_exti.c mh20xx_flash.c mh20xx_spi.c mh20xx_pwr.c mh20xx_crc.c mh20xx_adc.c mh20xx_comp.c mh20xx_i2c.c mh20xx_iwdg.c mh20xx_rtc.c mh20xx_tim.c mh20xx_wwdg.c mh20xx_dbgmcu.c
  group MH2030A_PORT
    ../dm9051_driver/ports/mh2030a/: mh2030a_board.c mh2030a_uip_clock.c dm9051_hal_mh2030a_spi1.c dm9051_hal_mh2030a_spi1_dma.c dm9051_hal_mh2030a_int.c
    ../dm9051_driver/ports/at32f403a/: dm9051_hal_at32f403a_spi1.c dm9051_hal_at32f403a_spi1_dma.c dm9051_hal_at32f403a_int.c at32f403a_board.c at32f403a_lwip_clock.c
  group dm9051/core
    ../dm9051_driver/core/src/: dm9051_core.c dm9051_debug.c
  group dm9051/lwip_adapter
    ../dm9051_driver/adapters/lwip/: dm9051_lwip.c
    ../dm9051_driver/ports/at32f403a/: ethernetif_at32f403a.c
  group lwip/port
    ../../../middlewares/3rd_party/lwip-2.1.2/port/: sys_arch.c ethernetif.c
  group lwip/core
    ../../../middlewares/3rd_party/lwip-2.1.2/src/core/: init.c def.c dns.c inet_chksum.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c timeouts.c
  group lwip/ipv4
    ../../../middlewares/3rd_party/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip/tcp_udp_altcp
    ../../../middlewares/3rd_party/lwip-2.1.2/src/core/: tcp.c tcp_in.c tcp_out.c udp.c altcp.c altcp_alloc.c altcp_tcp.c
  group lwip/netif
    ../../../middlewares/3rd_party/lwip-2.1.2/src/netif/: ethernet.c
  group lwip/apps_web
    ../../../apps/lwip_web2403v2_freelw/: lwip_web2403v2_freelw.c httpd.c fs_jjdynamic.c
  group dm9051/core
    ../dm9051_driver/hal/src/: dm9051_hal.c
