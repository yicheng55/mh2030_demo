# Keil uVision project DM9051A_lwip.uvprojx, settings and files
target MH2030A_DM9051_uIP (5060960::V5.06 update 7 (build 960)::.\ARMCC5.06)
  device: ARMCM0 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: MH2030A_DM9051_uIP +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,MH2030A_UIP_PORT,DM9051_MH2030A_DIAG=1,DM9051_TX_WAIT_DONE=1,DM9051_MH2030A_USE_DMA=1,DM9051_MH2030A_USE_IRQ=1
  c include: ..\USER;..\bsp;..\..\..\Libraries\MH20xxLib\inc;..\..\..\Libraries\CMSIS\Include;..\..\..\middlewares\3rd_party\uip\inc;..\..\..\middlewares\3rd_party\uip\port\at32f415_dm9051;..\..\..\apps\uip_dm9051_example_e1\example_uip\inc;..\..\..\apps\uip_dm9051_example_e1\uip_conf_inc;..\..\..\apps\uip_dm9051_example_e1\uip_app_src;..\..\..\apps\uip_dm9051_example_e1\uip_app_src\Eth_app\dhcpc;..\..\..\apps\uip_dm9051_example_e1\uip_app_src\Eth_app\resolv;..\..\..\apps\uip_dm9051_example_e1\uip_app_src\webserver\inc;..\..\..\drivers\dm9051_edriver_v1.6.1a_beta;..\port\mh2030a;..\port\uip;..\dm9051_driver\core\inc;..\dm9051_driver\hal\inc;..\dm9051_driver\adapters\uip;..\dm9051_driver\ports\mh2030a;..\dm9051_driver\examples\uip_mh2030a_demo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group USER
    ../../../Libraries/MH20xxLib/src/: system_mh20xx.c
    ../dm9051_driver/examples/uip_mh2030a_demo/: main_uip_mh2030a_smoke.c main_uip_mh2030a_demo.c
    ../dm9051_driver/examples/lwip_mh2030a_demo/: main_dm9051_lwip_example.c
    ../dm9051_driver/ports/mh2030a/: mh20xx_it.c
  group SYSTEM
    ../dm9051_driver/ports/mh2030a/: delay.c
  group CORE
    ../../../Libraries/CORE/: startup_mh20xx.s
  group FWLib
    ../../../Libraries/MH20xxLib/src/: mh20xx_usart.c mh20xx_rcc.c mh20xx_gpio.c mh20xx_dma.c mh20xx_misc.c mh20xx_syscfg.c mh20xx_exti.c mh20xx_flash.c mh20xx_spi.c mh20xx_pwr.c mh20xx_crc.c mh20xx_adc.c mh20xx_comp.c mh20xx_i2c.c mh20xx_iwdg.c mh20xx_rtc.c mh20xx_tim.c mh20xx_wwdg.c mh20xx_dbgmcu.c
  group MH2030A_PORT
    ../dm9051_driver/ports/mh2030a/: mh2030a_board.c mh2030a_uip_clock.c dm9051_hal_mh2030a_spi1.c dm9051_hal_mh2030a_spi1_dma.c dm9051_hal_mh2030a_int.c
  group DM9051_DRIVER_STAGING
    ../dm9051_driver/core/src/: dm9051_core.c dm9051_debug.c
    ../dm9051_driver/adapters/uip/: dm9051_uip.c dm9051_uip_stack.c
    ../../../apps/uip_dm9051_example_e1/uip_arch_src/UNIX/: main_unix.c
    ../dm9051_driver/ports/mh2030a/: dm9051_hal_mh2030a_spi1.c dm9051_hal_mh2030a_spi1_dma.c dm9051_hal_mh2030a_int.c
    ../dm9051_driver/examples/uip_mh2030a_demo/: dm9051_uip_mh2030a_smoke.c
  group UIP_CORE
    ../../../middlewares/3rd_party/uip/src/: uip.c uip_arp.c timer.c
  group UIP_APP
    ../../../apps/uip_dm9051_example_e1/uip_app_src/: app_call.c
    ../../../apps/uip_dm9051_example_e1/uip_app_src/Eth_app/debug_app/: debug_app.c
    ../../../apps/uip_dm9051_example_e1/uip_app_src/Eth_app/resolv/: resolv.c
    ../../../apps/uip_dm9051_example_e1/uip_app_src/webserver/src/DM/: httpd.c httpd-fs.c httpd-cgi-test1.c http-strings.c
    ../../../middlewares/3rd_party/uip/src/: psock.c
    ../../../apps/uip_dm9051_example_e1/uip_app_src/Eth_app/tcp_app/: tcp_app.c
  group dm9051/core
    ../dm9051_driver/core/src/: dm9051_core.c dm9051_debug.c
  group lwip/port
    ../../../middlewares/3rd_party/lwip-2.1.2/port/: sys_arch.c ethernetif.c
  group lwip/core
    ../../../middlewares/3rd_party/lwip-2.1.2/src/core/: init.c def.c dns.c inet_chksum.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c timeouts.c
  group lwip/ipv4
    ../../../middlewares/3rd_party/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip/tcp_udp_altcp
    ../../../middlewares/3rd_party/lwip-2.1.2/src/core/: tcp.c tcp_in.c tcp_out.c udp.c altcp.c altcp_alloc.c altcp_tcp.c
  group lwip/netif
    ../../../middlewares/3rd_party/lwip-2.1.2/src/netif/: ethernet.c
  group lwip/apps_web
    ../../../apps/lwip_web2403v2_freelw/: lwip_web2403v2_freelw.c httpd.c fs_jjdynamic.c
target MH2030A_DM9051_LWIP (5060960::V5.06 update 7 (build 960)::.\ARMCC5.06)
  device: ARMCM0 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: MH2030A_DM9051_LWIP +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,MH2030A_LWIP_PORT,NO_SYS=1,DM9051_MH2030A_DIAG=1,DM9051_TX_WAIT_DONE=1,DM9051_MH2030A_USE_DMA=1,DM9051_MH2030A_USE_IRQ=1
  c include: ..\USER;..\bsp;..\..\..\Libraries\MH20xxLib\inc;..\..\..\Libraries\CMSIS\Include;..\dm9051_driver\core\inc;..\dm9051_driver\hal\inc;..\dm9051_driver\ports\mh2030a;..\dm9051_driver\adapters\lwip;..\..\..\middlewares\3rd_party\lwip-2.1.2\src\include;..\..\..\middlewares\3rd_party\lwip-2.1.2\port;..\..\..\apps\lwip_web2403v2_freelw
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
