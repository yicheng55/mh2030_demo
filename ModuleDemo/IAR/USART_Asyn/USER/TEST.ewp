# IAR project TEST.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030CC ST STM32F030CC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: D:\Work\CurrencyCpu\MH资料\SVN\通用MCU\MH2030\MH2030开发套件\SDK\ModuleDemo\IAR\USART_Asyn\SYSTEM\delay; D:\Work\CurrencyCpu\MH资料\SVN\通用MCU\MH2030\MH2030开发套件\SDK\ModuleDemo\IAR\USART_Asyn\USER; D:\Work\CurrencyCpu\MH资料\SVN\通用MCU\MH2030\MH2030开发套件\SDK\Libraries\MH20xxLib\inc; D:\Work\CurrencyCpu\MH资料\SVN\通用MCU\MH2030\MH2030开发套件\SDK\Libraries\CMSIS\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CORE
    ./: startup_mh20xx_iar.s
  group FWLib
    ../../../../Libraries/MH20xxLib/src/: mh20xx_adc.c mh20xx_comp.c mh20xx_crc.c mh20xx_dbgmcu.c mh20xx_divqsrt.c mh20xx_dma.c mh20xx_exti.c mh20xx_flash.c mh20xx_gpio.c mh20xx_i2c.c mh20xx_iwdg.c mh20xx_misc.c mh20xx_opa.c mh20xx_pwr.c mh20xx_rcc.c mh20xx_rtc.c mh20xx_spi.c mh20xx_syscfg.c mh20xx_tim.c mh20xx_usart.c mh20xx_wwdg.c system_mh20xx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
  group USER
    ./: main.c mh20xx_it.c
