# Keil uVision project TEST.uvprojx, settings and files
target TEST (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030RCTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: USART +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\USER;..\..\..\..\Libraries\MH20xxLib\inc;..\..\..\..\Libraries\CMSIS\Include;..\SYSTEM\freertos
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group USER
    ./: main.c mh20xx_it.c
    ../../../../Libraries/MH20xxLib/src/: system_mh20xx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
  group CORE
    ../../../../Libraries/CORE/: startup_mh20xx.s
  group FWLib
    ../../../../Libraries/MH20xxLib/src/: mh20xx_usart.c mh20xx_rcc.c mh20xx_gpio.c mh20xx_crc.c mh20xx_dma.c mh20xx_misc.c mh20xx_syscfg.c mh20xx_dbgmcu.c mh20xx_adc.c mh20xx_comp.c mh20xx_exti.c mh20xx_flash.c mh20xx_i2c.c mh20xx_iwdg.c mh20xx_pwr.c mh20xx_rtc.c mh20xx_spi.c mh20xx_tim.c mh20xx_wwdg.c
  group Freertos
    ../SYSTEM/freertos/: croutine.c heap_2.c list.c port.c tasks.c queue.c timers.c
