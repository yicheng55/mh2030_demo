# Keil uVision project RCC.uvprojx, settings and files
target RCC (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: RCC +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\board;..\USER;..\..\..\..\Libraries\MH20xxLib\inc;..\..\..\..\Libraries\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group USER
    ./: main.c mh20xx_it.c
    ../../../../Libraries/MH20xxLib/src/: system_mh20xx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/board/: mh2030a_board.c
  group CORE
    ../../../../Libraries/CORE/: startup_mh20xx.s
  group FWLib
    ../../../../Libraries/MH20xxLib/src/: mh20xx_usart.c mh20xx_rcc.c mh20xx_gpio.c mh20xx_crc.c mh20xx_dma.c mh20xx_misc.c mh20xx_syscfg.c mh20xx_dbgmcu.c mh20xx_adc.c mh20xx_comp.c mh20xx_exti.c mh20xx_flash.c mh20xx_i2c.c mh20xx_iwdg.c mh20xx_pwr.c mh20xx_rtc.c mh20xx_spi.c mh20xx_tim.c mh20xx_wwdg.c
